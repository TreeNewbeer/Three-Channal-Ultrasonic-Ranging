# Keil uVision project SuperVoiceBall.uvproj, settings and files
target Project (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: SuperVoiceBall +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;.\oled
  group User
    ./: main.c
    ./Scr/: delay.c
  group Oled
    ./oled/: i2c_master.c Mid_oled.c oled.c
